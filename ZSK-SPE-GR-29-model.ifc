Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:33+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-SPE-GR-29
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-SPE-GR-29 Скамья «Лайт» со спинкой · чёрный гранит
In: Площадка
Description: Изделие бетонное благоустройства. Скамья «Лайт» со спинкой · чёрный гранит; Classification: 59.1.15.01-1076 Скамья (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-SPE-GR-29; ModelReference: Скамья «Лайт» со спинкой · чёрный гранит; ProductionYear: 2026; ArticleNumber: ZSK-SPE-GR-29
ORION_Изделие - Артикул: ZSK-SPE-GR-29; Артикул прежний: SD-SPE-GR-29; Наименование: Скамья «Лайт» со спинкой · чёрный гранит; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 2000×450×730 мм; Материал: Бетон; Цена: 104 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20911; Код КСИ: CPr>EDD070; Класс КСИ: Скамья; Коды КСР: 59.1.15.01-1076 … 59.1.15.02-0539
ADSK - ADSK_Наименование: Скамья «Лайт» со спинкой · чёрный гранит; ADSK_Марка: ZSK-SPE-GR-29; ADSK_Код изделия: 59.1.15.01-1076; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20911
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD070; ZSK_Артикул_прежний: SD-SPE-GR-29
Qto_ORION - Длина: 2000 mm; Ширина: 450 mm; Высота: 730 mm
